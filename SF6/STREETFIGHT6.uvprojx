# Keil uVision project STREETFIGHT6.uvprojx, settings and files
target Target 1 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STREETFIGHT6 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application
    ./: main.c
  group Board
    ./Board/: board_io.c board_io.h frame_clock.c frame_clock.h
  group Core
    ./Core/: action_player.c action_player.h action_queue.c action_queue.h controller_config.h controller_logic.c controller_logic.h controller_types.h input_bindings.h
  group Profiles
    ./Profiles/: character_profile.c character_profile.h current_profile.c
software components: CMSIS:CORE 4.3.0, Device:Startup 1.0.0
